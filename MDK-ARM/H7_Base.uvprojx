# Keil uVision project H7_Base.uvprojx, settings and files
target H7_Base (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: H7_Base +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,STB_DS_IMPLEMENTATION
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../CubotMiddleware;../new;../User;../CubotMiddleware/Algorithms;../CubotMiddleware/Devices;../CubotMiddleware/Drivers;../CubotMiddleware/Modules;../CubotMiddleware/Support;./H7_Base;../CubotMiddleware/Devices/BMI088;../CubotMiddleware/Devices/MPU6050;../MIddlewaves/ARM/DSP/Include;../MIddlewaves/ARM/DSP/Include/dsp;../MIddlewaves/ARM/DSP/Source/BasicMathFunctions;../MIddlewaves/ARM/DSP/Source/CommonTables;../MIddlewaves/ARM/DSP/Source/FastMathFunctions;../MIddlewaves/ARM/DSP/Source/MatrixFunctions;../MIddlewaves/ARM/DSP/Source/QuaternionMathFunctions
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../Src/: main.c gpio.c dma.c fdcan.c i2c.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Cubot/driver
    ../CubotMiddleware/Drivers/: driver_can.c driver_usart.c driver_iic.c driver_timer.c driver_counter.c driver_spi.c
  group Cubot/devices
    ./H7_Base/: referee.c
    ../CubotMiddleware/Devices/: motor.c dr16.c Supercap.c check.c bmi088.c et08.c
    ../new/: heat_control.c
  group Cubot/modules
    ../new/: holder.c
    ./H7_Base/: all_chassis.c
    ../CubotMiddleware/Modules/: reset.c reset.h shoot.c shoot.h ins.c
    ../User/: hardware_config.c
  group User/Config
    ../User/: control_logic.c
  group Cubot/Algorithm
    ../CubotMiddleware/Algorithms/: kalman.c pid.c kalman_filter.c quaternions_EKF.c user_lib.c
    ../CubotMiddleware/Devices/: filter.c
  group vision
    ../new/: brain.c
  group Cubot/MPU6050
    ../CubotMiddleware/Devices/MPU6050/: driver_iic.c mpu6050.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group MIddlewaves
    ../MIddlewaves/ARM/DSP/Source/MatrixFunctions/: MatrixFunctions.c
software components: CMSIS:CORE 4.3.0
